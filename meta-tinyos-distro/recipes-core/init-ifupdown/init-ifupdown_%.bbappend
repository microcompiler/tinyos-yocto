FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# udhcpc -i eth0 -x hostname:tinyos.local